## config/boards/shields/corne_right/Kconfig.defconfig
```kconfig
if SHIELD_CORNE_RIGHT

config ZMK_KEYBOARD_NAME
    default "corne_right"

endif
```
